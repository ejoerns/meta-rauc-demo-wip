RDEPENDS_${PN}_remove = "virtual/grub-bootconf"
DEPENDS += "rauc-qemu-grubconf"
