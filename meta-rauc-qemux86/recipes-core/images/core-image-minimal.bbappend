IMAGE_INSTALL_append = " kernel-image kernel-modules"
